# Repository andreikovari/Interview-Hardware-Test

File README.md:

# Interview-Hardware-Test
Interview Hardware Test files

## EAGLE design Buck Regulator.brd

Notes on the sheet:
Nanolabs Interview Test
The purpose of this test is to check both basic and advanced design actions in Eagle CAD
Down below you will find a list of primary and secondary goals. The completion of primary goals will allow you to enter the interview. Solving secondary goals will be translated to bonus points.
One can solve any task, in any desired order. We recommend to solve it on your own, with minimal external help. Any fraudulent attempt will be discovered in the technical interview.
May the odds be ever in your favour! :]
Primary goals
Secondary goals
- Snap R3 to grid
- Change package of R1 to 0402
- Rename net N$30 to FB and add label on net
- Rename first sheet to Datasheet
- Rename second sheet to Buck Regulator Schematic
- Add a fourth mounting hole
- In legend, add your name under Designer attribute
- Change value of C1 to 2.2uF
Schematic
- Change primary grid to 1mm, secondary to 0.1mm, make it visible
Layout
- Snap all components to grid
- Readjust the outline to be 60x40mm
- Add the mounting holes in each corner with an offset of 5mm from margins
- Add components inside outline and route traces
- Change text to a size of 1mm, 16% ratio and adjust location to be readable
- Add the text "Buck Regulator v0.1" on the top silkscreen layer where possible
- Export gerber files using OSH CAM, 2 layer, found under System examples > Third Party
- Add a type 3 minimum ripple configuration for the feedback structure (datasheet of regulator)
- Compute values for R2 and R3 to achieve the desired output (12V)
- Compute values for the added structure
- Add components for a 20V UVLO
- Add test points to the switching node, FB trace, UVLO and BST
- Add a Low Ripple Output test pad
- Reduce size of the layout to minimum (placement on both layers is allowed)
- Minimize critical current loops
- Change via mask limit to 0.5mm
- Round edges by 3.5mm
- Add a roundness of 10% to all SMT pads
- Export BOM, centroid and gerbers for OSH Park
- Print schematic to PDF, A4, color
- Export top and bottom layer images
- Generate Fusion360 3D model

Parts:
C1: 4.7uF/150V; C1812
C2: 1uF; C0603
C3: 10nF; C0603
C4: 4.7nF; C0603
C5, C6: 4.7uF; C0603
H1, H2, H3: MOUNT-HOLE3.2; 3,2
IC1: LM5017; SO-08-EP
L1: SDR1307-391KL
R1: 499k; R0603
R2, R3: R-EU_R0603; R0603
X1, X2: W237-102

Connections:
+12V: C4.1, C5.1, C6.1, L1.2, R2.2, X2.2
GND: C1.2, C2.2, C5.2, C6.2, IC1.1 (RTN), IC1.9 (RTN), R3.1, X1.2, X2.1
unnamed: C2.1, IC1.6 (VCC)
unnamed: C3.1, IC1.7 (BST)
unnamed: C3.2, IC1.8 (SW), L1.1
unnamed: C4.2, IC1.5 (FB), R2.1, R3.2
unnamed: IC1.4 (RON), R1.2
VIN_HV: C1.1, IC1.2 (VIN), IC1.3 (UV), R1.1, X1.1

Notes on the sheet:
Note: 60-100V is advised

Board: 2 copper layers, 16 parts (0 on the bottom side), 8 nets, no tracks yet.

## Commit log

2021-04-15 Added test files
